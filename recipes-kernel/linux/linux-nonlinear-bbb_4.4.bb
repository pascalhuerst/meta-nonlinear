DESCRIPTION = "Nonlinear Beagle Bone Black 4.4 Kernel"

require recipes-kernel/linux/linux-nonlinear.inc

SRCBRANCH = "nonlinear-am33xx-4.4.50"

COMPATIBLE_MACHINE = "beaglebone"
