EXTRA_OEMAKE += "\
       'CFLAGS=${CFLAGS} -Wno-error=stringop-truncation' \
"
